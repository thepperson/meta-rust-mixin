require recipes-devtools-mixin/rust/rust-source.inc
require recipes-devtools-mixin/rust/rust-snapshot.inc
require cargo.inc
BBCLASSEXTEND = "native nativesdk"
